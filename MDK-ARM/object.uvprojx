# Keil uVision project object.uvprojx, settings and files
target object (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: object +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Drivers\Inc;..\USER\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Drivers/: startup_stm32f10x_hd.s
  group User
    ../USER/Src/: main.c stm32f1xx_it.c
  group Drivers
    ../Drivers/Src/: sys.c delay.c gpio.c
